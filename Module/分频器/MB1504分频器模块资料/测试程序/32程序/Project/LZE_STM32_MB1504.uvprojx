# Keil uVision project LZE_STM32_MB1504.uvprojx, settings and files
target LZE_STM32_Template (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LZE_STM32_Template
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../User/: main.c Delay.c MB1504.c PeripheralInit.c
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/CoreSupport/: core_cm3.c
    ../CMSIS/DeviceSupport/STM32F10x/: system_stm32f10x.c
  group Startup
    ../CMSIS/DeviceSupport/STM32F10x/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 3.40.0
