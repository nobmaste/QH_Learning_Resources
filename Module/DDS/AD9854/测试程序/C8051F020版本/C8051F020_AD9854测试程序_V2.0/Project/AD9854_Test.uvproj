# Keil uVision project AD9854_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: AD9854_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Application;..\Drive
  group Application
    ../Application/: delay.c main.c system_init.c key.c
  group Drive
    ../Drive/: AD9854.c CharLCD.c
